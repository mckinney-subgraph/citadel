
inherit packagegroup

RDEPENDS_${PN} = "\
    wlroots \
    sway \
    xcb-util-xrm \
    sgflow \
    swaybg \
    swaylock \
    grim \
    slurp \
    wdisplays \
    polkit-gnome \
"

