
# Fix Python 3.9 build failure by using native python3 instead of host python3
#
#   https://gitlab.freedesktop.org/xorg/proto/xcbproto/-/merge_requests/8
#
inherit python3native

