FILESEXTRAPATHS_prepend := "${THISDIR}/libpam:"

SRC_URI += "file://pam.d/common-auth"
