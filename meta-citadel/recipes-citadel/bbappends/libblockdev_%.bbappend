
PACKAGECONFIG = "fs crypto parted mdraid kmod"
DEPENDS += "systemd"
