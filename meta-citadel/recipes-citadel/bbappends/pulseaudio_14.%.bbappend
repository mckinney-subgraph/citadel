RDEPENDS_pulseaudio-server_remove = "pulseaudio-module-console-kit"
RDEPENDS_remove = "pulseaudio-module-x11-cork-request \
                pulseaudio-module-x11-publish \
                pulseaudio-module-x11-xsmp \
"
PACKAGECONFIG_remove = "x11"
